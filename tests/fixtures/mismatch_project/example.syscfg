/*
 * @cliArgs --device "MSPM0G3507" --package "LQFP-64"
 * @versions {"tool":"1.26.2"}
 */
