/*
 * @cliArgs --device "MSPM0G3507" --package "LQFP-64"
 */
